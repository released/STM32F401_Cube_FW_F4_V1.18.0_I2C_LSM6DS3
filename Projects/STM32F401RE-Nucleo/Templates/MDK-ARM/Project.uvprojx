# Keil uVision project Project.uvprojx, settings and files
target STM32F4xx-Nucleo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4xx-Nucleo +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE,
  c misc: --C99
  c include: ..\Inc;..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\Inc\Kalman_Filter
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --diag_suppress=L6329
  group Drivers/BSP/STM32F4xx-Nucleo
    ../../../../Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_nucleo.c
  group Doc
    ../: readme.txt
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_flash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_uart.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_cryp.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_pcd.c stm32f4xx_hal_rtc.c stm32f4xx_hal_sram.c stm32f4xx_hal_i2s.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_can.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_rng.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_adc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_hash.c stm32f4xx_hal_hcd.c stm32f4xx_hal_irda.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dac.c stm32f4xx_hal_usart.c stm32f4xx_hal_spi.c stm32f4xx_hal_i2c.c stm32f4xx_hal_dma.c stm32f4xx_hal_crc.c stm32f4xx_hal.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_nand.c stm32f4xx_hal_tim.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_gpio.c stm32f4xx_ll_fsmc.c
  group Example/MDK-ARM
    ./: startup_stm32f401xe.s
  group Example/User
    ../Src/: stm32f4xx_it.c stm32f4xx_hal_msp.c main.c Custom_Button.c Hw_config.c macro.c MEMS_Calculate.c stm32f4xx_LSM6DS3.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Kalman_Filter
    ../Src/Kalman_Filter/: kalman_filter.c
software components: CMSIS:CORE 5.0.1
